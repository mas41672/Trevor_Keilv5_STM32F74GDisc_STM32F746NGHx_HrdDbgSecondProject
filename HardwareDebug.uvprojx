# Keil uVision project HardwareDebug.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: HardwareDebug
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Blinky.c setup.c
software components: CMSIS:CORE 5.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.2.0, Device:STM32Cube HAL:Common 1.0.4, Device:STM32Cube HAL:Cortex 1.0.4, Device:STM32Cube HAL:GPIO 1.0.4, Device:STM32Cube HAL:PWR 1.0.4, Device:STM32Cube HAL:RCC 1.0.4, Device:Startup 1.2.0
